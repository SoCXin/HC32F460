<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\adc_02_sa_event_trigger.ewp</path>
  </project>
  <batchBuild/>
</workspace>


