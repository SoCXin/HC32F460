# IAR project adc_13_adc1_adc2_sync.ewp, settings and files
configuration Debug (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: __DEBUG; HC32F460; USE_DEVICE_DRIVER_LIB
  ICCARM.CCIncludePath2: ..\..\..\..\..\mcu\common; ..\source; ..\..\..\..\..\driver\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: adc_13_adc1_adc2_sync.srec
  ILINK.IlinkOutputFile: adc_13_adc1_adc2_sync.out
  ILINK.IlinkIcfFile: hc32f460xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: HC32F460; USE_DEVICE_DRIVER_LIB
  ICCARM.CCIncludePath2: ..\..\..\..\..\mcu\common; ..\source; ..\..\..\..\..\driver\inc; ..\..\..\..\utility
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group (top)
    ../: Readme.txt
  group common
    ../../../../../mcu/common/: system_hc32f460.c
    ./: startup_hc32f460.s
  group driver
    ../../../../../driver/src/: hc32f460_utility.c hc32f460_pwc.c hc32f460_interrupts.c hc32f460_adc.c hc32f460_timer0.c hc32f460_clk.c hc32f460_icg.c hc32f460_efm.c hc32f460_sram.c hc32f460_gpio.c hc32f460_event_port.c hc32f460_dmac.c
  group source
    ../source/: main.c
