<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\adc_12_adc1_pga.ewp</path>
  </project>
  <batchBuild/>
</workspace>


