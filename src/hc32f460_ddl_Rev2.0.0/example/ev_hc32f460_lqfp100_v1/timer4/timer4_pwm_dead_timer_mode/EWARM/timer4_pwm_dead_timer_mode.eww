<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\timer4_pwm_dead_timer_mode.ewp</path>
  </project>
  <batchBuild/>
</workspace>


