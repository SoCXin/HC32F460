<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\dmac_link_list_pointer.ewp</path>
  </project>
  <batchBuild/>
</workspace>


