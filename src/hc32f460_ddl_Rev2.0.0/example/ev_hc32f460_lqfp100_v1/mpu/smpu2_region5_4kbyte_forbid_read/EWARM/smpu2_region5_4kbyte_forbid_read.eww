<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\smpu2_region5_4kbyte_forbid_read.ewp</path>
  </project>
  <batchBuild/>
</workspace>


