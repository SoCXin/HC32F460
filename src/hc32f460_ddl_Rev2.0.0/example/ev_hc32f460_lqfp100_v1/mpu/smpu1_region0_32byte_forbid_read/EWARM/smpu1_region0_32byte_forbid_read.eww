<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\smpu1_region0_32byte_forbid_read.ewp</path>
  </project>
  <batchBuild/>
</workspace>


