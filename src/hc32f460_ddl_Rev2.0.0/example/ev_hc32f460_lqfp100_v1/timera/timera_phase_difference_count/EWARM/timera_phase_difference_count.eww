<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\timera_phase_difference_count.ewp</path>
  </project>
  <batchBuild/>
</workspace>


