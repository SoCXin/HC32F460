<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\sd_multi_write_multi_read_1bit_dma_25mhz.ewp</path>
  </project>
  <batchBuild/>
</workspace>


