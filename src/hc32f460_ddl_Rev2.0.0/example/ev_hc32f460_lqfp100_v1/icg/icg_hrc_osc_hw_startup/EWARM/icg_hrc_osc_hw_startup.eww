<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\icg_hrc_osc_hw_startup.ewp</path>
  </project>
  <batchBuild/>
</workspace>


