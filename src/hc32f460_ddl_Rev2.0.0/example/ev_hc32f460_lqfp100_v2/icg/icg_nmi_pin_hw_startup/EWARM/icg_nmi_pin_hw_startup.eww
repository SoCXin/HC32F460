<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\icg_nmi_pin_hw_startup.ewp</path>
  </project>
  <batchBuild/>
</workspace>


