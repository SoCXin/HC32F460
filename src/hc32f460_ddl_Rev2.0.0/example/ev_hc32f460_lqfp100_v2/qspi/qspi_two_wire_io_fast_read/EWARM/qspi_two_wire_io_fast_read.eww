<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\qspi_two_wire_io_fast_read.ewp</path>
  </project>
  <batchBuild/>
</workspace>


