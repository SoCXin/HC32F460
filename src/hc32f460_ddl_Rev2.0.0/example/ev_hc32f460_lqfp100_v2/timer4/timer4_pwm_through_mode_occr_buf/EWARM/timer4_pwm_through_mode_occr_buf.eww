<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\timer4_pwm_through_mode_occr_buf.ewp</path>
  </project>
  <batchBuild/>
</workspace>


