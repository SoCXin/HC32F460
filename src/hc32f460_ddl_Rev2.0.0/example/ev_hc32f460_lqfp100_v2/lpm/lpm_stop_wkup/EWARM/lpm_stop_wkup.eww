<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\lpm_stop_wkup.ewp</path>
  </project>
  <batchBuild/>
</workspace>


