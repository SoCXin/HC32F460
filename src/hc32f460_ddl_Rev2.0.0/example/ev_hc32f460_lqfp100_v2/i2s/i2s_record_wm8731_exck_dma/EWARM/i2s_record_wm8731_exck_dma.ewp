# IAR project i2s_record_wm8731_exck_dma.ewp, settings and files
configuration Debug (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: __DEBUG; HC32F460; USE_DEVICE_DRIVER_LIB
  ICCARM.CCIncludePath2: ..\..\..\..\..\mcu\common; ..\source; ..\..\..\..\..\driver\inc; ..\..\..\..\..\midware\wm8731\inc; ..\..\..\..\..\bsp\ev_hc32f460_lqfp100_v2
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: i2s_record_wm8731_exck_dma.srec
  ILINK.IlinkOutputFile: i2s_record_wm8731_exck_dma.out
  ILINK.IlinkIcfFile: hc32f460xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: HC32F460; USE_DEVICE_DRIVER_LIB
  ICCARM.CCIncludePath2: ..\..\..\..\..\mcu\common; ..\source; ..\..\..\..\..\driver\inc; ..\..\..\..\..\midware\wm8731\inc; ..\..\..\..\..\bsp\ev_hc32f460_lqfp100_v2; ..\..\..\..\utility
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group (top)
    ../: Readme.txt
  group common
    ../../../../../mcu/common/: system_hc32f460.c
    ./: startup_hc32f460.s
  group driver
    ../../../../../driver/src/: hc32f460_utility.c hc32f460_pwc.c hc32f460_interrupts.c hc32f460_clk.c hc32f460_icg.c hc32f460_efm.c hc32f460_i2s.c hc32f460_sram.c hc32f460_i2c.c hc32f460_gpio.c hc32f460_exint_nmi_swi.c hc32f460_dmac.c hc32f460_keyscan.c
  group midware/wm8731
    ../../../../../midware/wm8731/src/: data_sound_441_i2s.c data_sound_8k_i2s.c wm8731.c
  group bsp/ev_hc32f460_lqfp100_v2
    ../../../../../bsp/ev_hc32f460_lqfp100_v2/: ev_hc32f460_lqfp100_v2.c
  group source
    ../source/: main.c
