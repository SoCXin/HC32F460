<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\spi_three_wire_tx_and_rx_polling.ewp</path>
  </project>
  <batchBuild/>
</workspace>


