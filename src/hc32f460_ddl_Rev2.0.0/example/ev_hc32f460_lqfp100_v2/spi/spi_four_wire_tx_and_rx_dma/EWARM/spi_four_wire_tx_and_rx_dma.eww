<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\spi_four_wire_tx_and_rx_dma.ewp</path>
  </project>
  <batchBuild/>
</workspace>


