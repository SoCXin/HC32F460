# IAR project project.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: USE_DEVICE_DRIVER_LIB; HC32F46x; __DEBUG; RT_USING_DLIBC; _DLIB_FILE_DESCRIPTOR; _DLIB_THREAD_SUPPORT
  ICCARM.CCIncludePath2: Libraries\CMSIS\DeviceSupport\HDSC\HC32F46x\Include; ..\..\components\dfs\filesystems\elmfat; applications; ..\..\components\libc\compilers\dlib; drivers; ..\..\components\libc\compilers\common; Libraries\CMSIS\CoreSupport\Include; ..\..\include; ..\..\libcpu\arm\cortex-m4; Libraries\HC32F46x_StdPeriph_Driver\inc; ..\..\components\dfs\include; ..\..\components\drivers\include; ..\..\libcpu\arm\common; .; ..\..\components\finsh; ..\..\components\drivers\spi; ..\..\components\dfs\filesystems\devfs
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: rtthread.bin
  ILINK.IlinkOutputFile: rtthread.out
  ILINK.IlinkIcfFile: drivers\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: __DEBUG; USE_DEVICE_DRIVER_LIB; HC32F46x; __DEBUG; RT_USING_DLIBC; _DLIB_FILE_DESCRIPTOR; _DLIB_THREAD_SUPPORT
  group Kernel
    ../../src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: main.c
  group Drivers
    drivers/: board.c drv_i2c.c drv_usart.c hc32_platform.c
  group HC32_StdPeriph
    Libraries/CMSIS/DeviceSupport/HDSC/HC32F46x/Source/: system_hc32f46x.c
    Libraries/HC32F46x_StdPeriph_Driver/src/: hc32f46x_adc.c hc32f46x_aes.c hc32f46x_can.c hc32f46x_clk.c hc32f46x_cmp.c hc32f46x_crc.c hc32f46x_dcu.c hc32f46x_dmac.c hc32f46x_efm.c hc32f46x_emb.c hc32f46x_event_port.c hc32f46x_exint_nmi_swi.c hc32f46x_gpio.c hc32f46x_hash.c hc32f46x_i2c.c hc32f46x_i2s.c hc32f46x_icg.c hc32f46x_interrupts.c hc32f46x_keyscan.c hc32f46x_mpu.c hc32f46x_ots.c hc32f46x_pwc.c hc32f46x_qspi.c hc32f46x_rmu.c hc32f46x_rtc.c hc32f46x_sdioc.c hc32f46x_spi.c hc32f46x_sram.c hc32f46x_swdt.c hc32f46x_timer0.c hc32f46x_timer4_cnt.c hc32f46x_timer4_emb.c hc32f46x_timer4_oco.c hc32f46x_timer4_pwm.c hc32f46x_timer4_sevt.c hc32f46x_timer6.c hc32f46x_timera.c hc32f46x_trng.c hc32f46x_usart.c hc32f46x_utility.c hc32f46x_wdt.c
    Libraries/CMSIS/DeviceSupport/HDSC/HC32F46x/Source/IAR/: startup_hc32f46x.s
  group cpu
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../libcpu/arm/cortex-m4/: cpuport.c context_iar.S
  group Filesystem
    ../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    ../../components/dfs/filesystems/devfs/: devfs.c
    ../../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    ../../components/dfs/filesystems/elmfat/option/: ccsbcs.c
  group DeviceDrivers
    ../../components/drivers/i2c/: i2c_core.c i2c_dev.c
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/rtc/: rtc.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/spi/: spi_core.c spi_dev.c qspi_core.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../components/drivers/watchdog/: watchdog.c
  group finsh
    ../../components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c
  group libc
    ../../components/libc/compilers/common/: gmtime_r.c
  group dlib
    ../../components/libc/compilers/dlib/: environ.c libc.c rmtx.c stdio.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c time.c
