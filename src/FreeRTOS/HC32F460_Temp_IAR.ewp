# IAR project HC32F460_Temp_IAR.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: HC32F46x; USE_DEVICE_DRIVER_LIB; __TARGET_FPU_VFP; __FPU_PRESENT=1; ARM_MATH_CM4; ARM_MATH_MATRIX_CHECK; ARM_MATH_ROUNDING
  ICCARM.CCIncludePath2: common; driver\inc; driver\src; driver; usb_lib; usb_lib\ctl_drv; usb_lib\device_class\hid; usb_lib\device_class; usb_lib\device_core; $TOOLKIT_DIR$\CMSIS\Include; PeripheralDriver; midware\OLED; midware\sd_card\inc; midware\sd_card\src; midware\sd_card; midware\wm8731\inc; midware\wm8731\src; midware\wm8731; App; FreeRTOS; FreeRTOS\CMSIS_RTOS; FreeRTOS\include; FreeRTOS\portable; FreeRTOS\portable\MemMang; FreeRTOS\portable\RVDS; FreeRTOS\portable\RVDS\ARM_CM4F; $TOOLKIT_DIR$\CMSIS\Core\Include; FileSystem\inc; usb_lib\device_class\msc; RTT; midware\w25qxx\inc; Tasks; $TOOLKIT_DIR$\..\..\Embedded Workbench 8.4\arm\CMSIS\DSP\Include; midware\wavefile; midware\AT24C02
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: FreeRTOS; FreeRTOS\CMSIS_RTOS; FreeRTOS\portable\RVDS\ARM_CM4F; FreeRTOS\portable\RVDS; FreeRTOS\portable\MemMang; FreeRTOS\portable; App
  OBJCOPY.OOCOutputFile: HC32F460_Temp_IAR.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: HC32F46x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  group App
    App/: main.c usb_bsp_template.c usbd_desc.c usbd_storage_msd.c usbd_usr.c User_Task.c
  group common
    common/: startup_hc32f46x.s system_hc32f46x.c
  group Debug_RTT
    RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
  group driver
    driver/src/: hc32f46x_adc.c hc32f46x_aes.c hc32f46x_can.c hc32f46x_clk.c hc32f46x_cmp.c hc32f46x_dcu.c hc32f46x_dmac.c hc32f46x_efm.c hc32f46x_emb.c hc32f46x_event_port.c hc32f46x_exint_nmi_swi.c hc32f46x_gpio.c hc32f46x_hash.c hc32f46x_i2c.c hc32f46x_i2s.c hc32f46x_icg.c hc32f46x_interrupts.c hc32f46x_keyscan.c hc32f46x_mpu.c hc32f46x_ots.c hc32f46x_pwc.c hc32f46x_qspi.c hc32f46x_rmu.c hc32f46x_rtc.c hc32f46x_sdioc.c hc32f46x_spi.c hc32f46x_sram.c hc32f46x_swdt.c hc32f46x_timer0.c hc32f46x_timer4_cnt.c hc32f46x_timer4_emb.c hc32f46x_timer4_oco.c hc32f46x_timer4_pwm.c hc32f46x_timer4_sevt.c hc32f46x_timer6.c hc32f46x_timera.c hc32f46x_trng.c hc32f46x_usart.c hc32f46x_utility.c hc32f46x_wdt.c
  group FileSystem
    FileSystem/src/: diskio.c fattime.c ff.c
  group FreeRTOS
    FreeRTOS/CMSIS_RTOS/: cmsis_os.c
    FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    FreeRTOS/portable/MemMang/: heap_4.c
    FreeRTOS/portable/RVDS/ARM_CM4F/: port.c portasm.s
  group midware
    midware/wm8731/src/: data_sound_441_i2s.c data_sound_8k_i2s.c wm8731.c
    midware/OLED/: OLED.c OLED_port.c
    midware/sd_card/src/: sd_card.c sdmmc_cmd.c
    midware/w25qxx/src/: w25qxx.c
  group PeripheralDriver
    PeripheralDriver/: bsp_dma.c bsp_dma.h bsp_i2c_dma.c bsp_i2c_dma.h bsp_interrupt.c bsp_interrupt.h bsp_mco.c bsp_mco.h HW_I2C.c Hw_MPU.c Hw_Uart4.c Hw_Uart4.h System_Clk.c System_PowerDown.c System_PowerDown.h User_ADC.c User_CAN.c User_Crypto.c User_DCU.c User_DMA.c User_Gpio.c User_I2C.c User_I2S.c User_OTS.c User_PWC.c User_QSPI.c User_RTC.c User_SDIO.c User_Timer.c User_Timer4.c User_Timer6.c User_TimerA.c User_TRNG.c User_Uart.c
  group Tasks
    Tasks/: Task_ADC.c Task_display.c Task_FileSystem.c Task_Key.c Task_LED.c Task_USB.c
  group usb_core
    usb_lib/device_core/: usbd_core.c usbd_ioreq.c usbd_req.c
  group usb_ctrl
    usb_lib/ctl_drv/: usb_core.c usb_dcd.c usb_dcd_int.c usb_otg.c
  group usb_msc
    usb_lib/device_class/msc/: usbd_msc_bot.c usbd_msc_bot.h usbd_msc_core.c usbd_msc_core.h usbd_msc_data.c usbd_msc_data.h usbd_msc_mem.h usbd_msc_scsi.c usbd_msc_scsi.h
