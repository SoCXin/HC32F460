<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\HC32F460_Temp_IAR.ewp</path>
  </project>
  <batchBuild/>
</workspace>


