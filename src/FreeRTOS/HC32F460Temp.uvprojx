# Keil uVision project HC32F460Temp.uvprojx, settings and files
target HC32F460 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32F460KETA HDSC
  pack: HDSC.HC32F460.1.0.7
  cpu: IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) IROM(0x00000000,0x80000) IROM2(0x03000C00,0x003FC) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HC32F460Temp +hex
  AfterMake: fromelf  --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: HC32F46x,USE_DEVICE_DRIVER_LIB,__TARGET_FPU_VFP,__FPU_PRESENT=1,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__MPU_PRESENT=1
  c misc: --diag_suppress=186,66
  c include: .\common;.\driver\src;.\driver\inc;.\driver;.\usb_lib\ctl_drv;.\usb_lib\device_class\hid;.\usb_lib\device_core;.\App;.\FreeRTOS;.\FreeRTOS\include;.\FreeRTOS\CMSIS_RTOS;.\FreeRTOS\portable\MemMang;.\FreeRTOS\portable\RVDS;.\PeripheralDriver;.\midware\OLED;.\midware\OLED;.\midware\sd_card\inc;.\midware\sd_card\src;.\midware\sd_card;.\midware\wm8731;.\midware\wm8731\inc;.\midware\wm8731\src;.\FreeRTOS\portable\MDK;.\FileSystem\inc;.\midware\NRF24L01;.\midware\MLX9061x;.\RTT;.\midware\WL2400PTC;.\midware;.\usb_lib\device_class\hid_custom;.\usb_lib\device_class\hid_msc_wrapper;.\usb_lib\device_class\msc;.\midware\w25qxx\inc;.\Cpp_Class;.\midware\FFT;.\midware\AT24C02;.\midware\wavefile
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  group Hal_lib
    ./driver/src/: hc32f46x_adc.c hc32f46x_aes.c hc32f46x_can.c hc32f46x_clk.c hc32f46x_cmp.c hc32f46x_dcu.c hc32f46x_dmac.c hc32f46x_efm.c hc32f46x_emb.c hc32f46x_event_port.c hc32f46x_exint_nmi_swi.c hc32f46x_gpio.c hc32f46x_hash.c hc32f46x_i2c.c hc32f46x_i2s.c hc32f46x_icg.c hc32f46x_interrupts.c hc32f46x_keyscan.c hc32f46x_mpu.c hc32f46x_ots.c hc32f46x_pwc.c hc32f46x_qspi.c hc32f46x_rmu.c hc32f46x_rtc.c hc32f46x_sdioc.c hc32f46x_spi.c hc32f46x_sram.c hc32f46x_swdt.c hc32f46x_timer0.c hc32f46x_timer4_cnt.c hc32f46x_timer4_emb.c hc32f46x_timer4_oco.c hc32f46x_timer4_pwm.c hc32f46x_timer4_sevt.c hc32f46x_timer6.c hc32f46x_timera.c hc32f46x_trng.c hc32f46x_usart.c hc32f46x_utility.c hc32f46x_wdt.c
  group App
    ./App/: main.c User_Task.c usb_bsp_template.c usbd_desc.c usbd_storage_msd.c usbd_usr.c
  group Common
    ./common/: system_hc32f46x.c ddl_config.h hc32_common.h hc32_ddl.h HC32F46x.h system_hc32f46x.h
    ./common/MDK/: startup_hc32f46x.s
  group usb_ctl
    ./usb_lib/ctl_drv/: usb_core.c usb_dcd.c usb_dcd_int.c usb_otg.c
  group usb_core
    ./usb_lib/device_core/: usbd_core.c usbd_ioreq.c usbd_req.c
  group PeripheralDriver
    ./PeripheralDriver/: User_Gpio.c System_Clk.c User_OTS.c User_ADC.c User_CAN.c User_Crypto.c User_DCU.c HW_I2C.c HW_I2C.h bsp_dma.c bsp_dma.h bsp_i2c_dma.c bsp_i2c_dma.h bsp_interrupt.c bsp_interrupt.h bsp_i2c_gpio.c bsp_i2c_gpio.h bsp_mco.c bsp_mco.h bsp_efm.c bsp_efm.h hd_sdio.c Hw_Uart4.c System_PowerDown.c Hw_SPI3.c
  group FreeRTOS
    ./FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ./FreeRTOS/portable/MemMang/: heap_4.c
    ./FreeRTOS/CMSIS_RTOS/: cmsis_os.c
    ./FreeRTOS/portable/MDK/: port.c
  group Midware
    ./midware/wm8731/src/: data_sound_8k_i2s.c data_sound_441_i2s.c wm8731.c
    ./midware/sd_card/src/: sdmmc_cmd.c sd_card.c
    ./midware/AT24C02/: AT24C02.c AT24C02.h
    ./midware/FFT/: User_FFT.c User_FFT.h
    ./midware/OLED/: OLED.c OLED_port.c OLED_FRONT.h
    ./midware/w25qxx/src/: w25qxx.c
    ./midware/w25qxx/inc/: w25qxx.h
    ./midware/wavefile/: wavefile.c wavefile.h
  group FileSystem
    ./FileSystem/src/: diskio.c fattime.c ff.c
  group Debug_RTT
    ./RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
  group usb_msc
    ./usb_lib/device_class/msc/: usbd_msc_bot.c usbd_msc_bot.h usbd_msc_core.c usbd_msc_core.h usbd_msc_data.c usbd_msc_data.h usbd_msc_mem.h usbd_msc_scsi.c usbd_msc_scsi.h
  group Task
    ./Tasks/: Task_FileSystem.h Task_FileSystem.c Task_Key.c Task_Key.h Task_LED.c Task_LED.h Task_display.h Task_display.c Tasks_include.h Task_ADC.c Task_ADC.h Task_USB.c Task_USB.h
  group Cpp_Class
    ./Cpp_Class/: Class_SPI.cpp Test.cpp Class_SPI.h Test.h Class_I2C.cpp Class_I2C.h
software components: CMSIS:CORE 5.4.0, CMSIS:DSP 1.8.0
