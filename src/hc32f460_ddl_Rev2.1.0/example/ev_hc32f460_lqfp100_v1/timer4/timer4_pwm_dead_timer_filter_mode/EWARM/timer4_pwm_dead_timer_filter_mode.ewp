# IAR project timer4_pwm_dead_timer_filter_mode.ewp, settings and files
configuration Debug (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: __DEBUG; HC32F460; USE_DEVICE_DRIVER_LIB
  ICCARM.CCIncludePath2: ..\..\..\..\..\mcu\common; ..\source; ..\..\..\..\..\driver\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: timer4_pwm_dead_timer_filter_mode.srec
  ILINK.IlinkOutputFile: timer4_pwm_dead_timer_filter_mode.out
  ILINK.IlinkIcfFile: hc32f460xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: HC32F460; USE_DEVICE_DRIVER_LIB
  ICCARM.CCIncludePath2: ..\..\..\..\..\mcu\common; ..\source; ..\..\..\..\..\driver\inc; ..\..\..\..\utility
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group (top)
    ../: Readme.txt
  group common
    ../../../../../mcu/common/: system_hc32f460.c
    ./: startup_hc32f460.s
  group driver
    ../../../../../driver/src/: hc32f460_pwc.c hc32f460_clk.c hc32f460_timer4_pwm.c hc32f460_utility.c hc32f460_icg.c hc32f460_gpio.c hc32f460_timer4_oco.c hc32f460_interrupts.c hc32f460_timer4_cnt.c
  group source
    ../source/: main.c
