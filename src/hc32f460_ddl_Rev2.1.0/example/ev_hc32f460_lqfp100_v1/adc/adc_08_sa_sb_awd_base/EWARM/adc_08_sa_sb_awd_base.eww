<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\adc_08_sa_sb_awd_base.ewp</path>
  </project>
  <batchBuild/>
</workspace>


