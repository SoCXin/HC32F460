<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\adc_05_sa_sb_interrupt.ewp</path>
  </project>
  <batchBuild/>
</workspace>


