<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\i2s_play_wm8731_exck_8k.ewp</path>
  </project>
  <batchBuild/>
</workspace>


