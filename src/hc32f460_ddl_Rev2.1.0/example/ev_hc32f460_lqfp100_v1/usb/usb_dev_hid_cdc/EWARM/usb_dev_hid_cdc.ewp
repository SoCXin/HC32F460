# IAR project usb_dev_hid_cdc.ewp, settings and files
configuration Debug (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: __DEBUG; HC32F460; USE_DEVICE_DRIVER_LIB
  ICCARM.CCIncludePath2: ..\..\..\..\..\mcu\common; ..\source; ..\..\..\..\..\driver\inc; ..\..\..\..\..\bsp\ev_hc32f460_lqfp100_v1; ..\..\..\..\..\usb_lib\usb_core; ..\..\..\..\..\usb_lib\device_core; ..\..\..\..\..\usb_lib\device_class\custom_hid; ..\..\..\..\..\usb_lib\device_class\single_cdc; ..\..\..\..\..\usb_lib\device_class\hid_cdc_composite
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: usb_dev_hid_cdc.srec
  ILINK.IlinkOutputFile: usb_dev_hid_cdc.out
  ILINK.IlinkIcfFile: hc32f460xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: HC32F460; USE_DEVICE_DRIVER_LIB
  ICCARM.CCIncludePath2: ..\..\..\..\..\mcu\common; ..\source; ..\..\..\..\..\driver\inc; ..\..\..\..\..\bsp\ev_hc32f460_lqfp100_v1; ..\..\..\..\..\usb_lib\usb_core; ..\..\..\..\..\usb_lib\device_core; ..\..\..\..\..\usb_lib\device_class\custom_hid; ..\..\..\..\..\usb_lib\device_class\single_cdc; ..\..\..\..\..\usb_lib\device_class\hid_cdc_composite; ..\..\..\..\utility
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group (top)
    ../: Readme.txt
  group common
    ../../../../../mcu/common/: system_hc32f460.c
    ./: startup_hc32f460.s
  group driver
    ../../../../../driver/src/: hc32f460_pwc.c hc32f460_clk.c hc32f460_keyscan.c hc32f460_efm.c hc32f460_utility.c hc32f460_sram.c hc32f460_icg.c hc32f460_usart.c hc32f460_gpio.c hc32f460_exint_nmi_swi.c hc32f460_interrupts.c
  group bsp/ev_hc32f460_lqfp100_v1
    ../../../../../bsp/ev_hc32f460_lqfp100_v1/: ev_hc32f460_lqfp100_v1.c
  group usb_lib/usb_core
    ../../../../../usb_lib/usb_core/: usb_core_driver.c
  group usb_lib/device_core
    ../../../../../usb_lib/device_core/: usb_dev_core.c usb_dev_ctrleptrans.c usb_dev_driver.c usb_dev_int.c usb_dev_stdreq.c
  group usb_lib/device_class/custom_hid
    ../../../../../usb_lib/device_class/custom_hid/: usb_dev_custom_hid_class.c
  group usb_lib/device_class/single_cdc
    ../../../../../usb_lib/device_class/single_cdc/: usb_dev_cdc_class.c
  group usb_lib/device_class/hid_cdc_composite
    ../../../../../usb_lib/device_class/hid_cdc_composite/: usb_dev_hid_cdc_wrapper.c
  group source
    ../source/: main.c
    ..//source/: cdc_data_process.c usb_bsp.c usb_dev_desc.c usb_dev_user.c
