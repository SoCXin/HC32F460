<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\usb_dev_keyboard.ewp</path>
  </project>
  <batchBuild/>
</workspace>


