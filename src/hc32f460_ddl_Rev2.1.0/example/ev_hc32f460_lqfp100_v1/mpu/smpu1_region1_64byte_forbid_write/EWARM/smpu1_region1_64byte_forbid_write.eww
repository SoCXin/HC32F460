<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\smpu1_region1_64byte_forbid_write.ewp</path>
  </project>
  <batchBuild/>
</workspace>


