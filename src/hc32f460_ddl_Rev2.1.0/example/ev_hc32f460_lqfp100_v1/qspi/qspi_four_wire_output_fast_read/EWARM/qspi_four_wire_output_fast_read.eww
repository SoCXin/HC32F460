<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\qspi_four_wire_output_fast_read.ewp</path>
  </project>
  <batchBuild/>
</workspace>


