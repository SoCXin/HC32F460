<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\efm_seqence_program.ewp</path>
  </project>
  <batchBuild/>
</workspace>


