<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\clk_fcm_exref_err_irq.ewp</path>
  </project>
  <batchBuild/>
</workspace>


