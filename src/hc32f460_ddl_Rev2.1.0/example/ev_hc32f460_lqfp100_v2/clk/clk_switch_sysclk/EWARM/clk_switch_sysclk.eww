<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\clk_switch_sysclk.ewp</path>
  </project>
  <batchBuild/>
</workspace>


