<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\smpu2_region3_2kbyte_forbid_write.ewp</path>
  </project>
  <batchBuild/>
</workspace>


