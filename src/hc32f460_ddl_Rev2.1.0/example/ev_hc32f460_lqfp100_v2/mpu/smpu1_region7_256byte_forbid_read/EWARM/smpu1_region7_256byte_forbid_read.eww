<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\smpu1_region7_256byte_forbid_read.ewp</path>
  </project>
  <batchBuild/>
</workspace>


