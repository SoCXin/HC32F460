<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\sc_rx_atr_int.ewp</path>
  </project>
  <batchBuild/>
</workspace>


