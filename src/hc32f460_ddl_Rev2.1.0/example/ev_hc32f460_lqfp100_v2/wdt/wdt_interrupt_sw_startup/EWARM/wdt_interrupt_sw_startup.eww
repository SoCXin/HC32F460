<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\wdt_interrupt_sw_startup.ewp</path>
  </project>
  <batchBuild/>
</workspace>


