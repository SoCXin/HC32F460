# IAR project usb_host_hid_msc.ewp, settings and files
configuration Debug (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: __DEBUG; HC32F460; USE_DEVICE_DRIVER_LIB
  ICCARM.CCIncludePath2: ..\..\..\..\..\mcu\common; ..\source; ..\..\..\..\..\driver\inc; ..\..\..\..\..\bsp\ev_hc32f460_lqfp100_v2; ..\..\..\..\..\usb_lib\usb_core; ..\..\..\..\..\usb_lib\host_core; ..\..\..\..\..\usb_lib\host_class\msc; ..\..\..\..\..\usb_lib\host_class\hid
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: usb_host_hid_msc.srec
  ILINK.IlinkOutputFile: usb_host_hid_msc.out
  ILINK.IlinkIcfFile: hc32f460xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: HC32F460; USE_DEVICE_DRIVER_LIB
  ICCARM.CCIncludePath2: ..\..\..\..\..\mcu\common; ..\source; ..\..\..\..\..\driver\inc; ..\..\..\..\..\bsp\ev_hc32f460_lqfp100_v2; ..\..\..\..\..\usb_lib\usb_core; ..\..\..\..\..\usb_lib\host_core; ..\..\..\..\..\usb_lib\host_class\msc; ..\..\..\..\..\usb_lib\host_class\hid; ..\..\..\..\utility
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group (top)
    ../: Readme.txt
  group common
    ../../../../../mcu/common/: system_hc32f460.c
    ./: startup_hc32f460.s
  group driver
    ../../../../../driver/src/: hc32f460_pwc.c hc32f460_clk.c hc32f460_keyscan.c hc32f460_efm.c hc32f460_utility.c hc32f460_sram.c hc32f460_icg.c hc32f460_gpio.c hc32f460_exint_nmi_swi.c hc32f460_interrupts.c
  group bsp/ev_hc32f460_lqfp100_v2
    ../../../../../bsp/ev_hc32f460_lqfp100_v2/: ev_hc32f460_lqfp100_v2.c
  group usb_lib/usb_core
    ../../../../../usb_lib/usb_core/: usb_core_driver.c
  group usb_lib/host_core
    ../../../../../usb_lib/host_core/: usb_host_cfgch.c usb_host_core.c usb_host_ctrltrans.c usb_host_driver.c usb_host_int.c usb_host_stdreq.c
  group usb_lib/host_class/msc
    ../../../../../usb_lib/host_class/msc/: usb_host_msc_bot.c usb_host_msc_class.c usb_host_msc_fatfs.c usb_host_msc_scsi.c
  group usb_lib/host_class/hid
    ../../../../../usb_lib/host_class/hid/: usb_host_hid_class.c usb_host_hid_keyboardapp.c usb_host_hid_mouseapp.c
  group source
    ../source/: main.c
    ..//source/: usb_bsp.c usb_host_user.c usb_host_user_print.c
