<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\timer4_oco_single_high_ch.ewp</path>
  </project>
  <batchBuild/>
</workspace>


