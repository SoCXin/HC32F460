<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\timer4_cnt_triangular_wave_mode.ewp</path>
  </project>
  <batchBuild/>
</workspace>


