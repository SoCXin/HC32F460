# IAR project HC32F460JETA.ewp, settings and files
configuration Debug (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: HC32F460; __DEBUG
  ICCARM.CCIncludePath2: ..\..\common; ..\source
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: hc32f460jeta.srec
  ILINK.IlinkOutputFile: hc32f460jeta.out
  ILINK.IlinkIcfFile: config\HC32F460xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: HC32F460
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group common
    ../../common/: system_hc32f460jeta.c
    ./: startup_hc32f460jeta.s
  group source
    ../source/: main.c
